# Keil uVision project FOTA-ITI-Project.uvprojx, settings and files
target FOTA-ITI-Project (6190000::V6.19::ARMCLANG)
  device: STM32F401RCTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: FOTA-ITI-Project
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\APP;.\APP\LIB;.\HAL;.\MCAL;.\MCAL\FLASH;.\MCAL\GPIO;.\MCAL\RCC;.\MCAL\SYSTK;.\HAL\LCD
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group APP
    ./APP/: main.c
    ./APP/LIB/: BIT_MATH.h STD_TYPES.h
  group HAL
    ./HAL/LCD/: LCD_Config.h LCD_Interface.h LCD_Private.h LCD_Program.c
  group MCAL
    ./MCAL/FLASH/: FLASH_Config.h FLASH_Interface.h FLASH_Private.h FLASH_Program.c
    ./MCAL/RCC/: RCC_Config.h RCC_Interface.h RCC_Private.h RCC_Program.c
    ./MCAL/GPIO/: GPIO_Config.h GPIO_Interface.h GPIO_Private.h GPIO_Program.c
    ./MCAL/SYSTK/: SYSTK_Config.h SYSTK_Interface.h SYSTK_Private.h SYSTK_Program.c
software components: CMSIS:CORE 5.6.0, Device:Startup 2.6.3
